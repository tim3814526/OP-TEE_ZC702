COMPATIBLE_MACHINE_zynq = "zynq-generic|ultra96-zynq"
